# Keil uVision project wireless.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: wireless +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .\Libraries\CMSIS\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\STM32F4xx_StdPeriph_Driver\src;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Default;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Default
    ./Default/: startup_stm32f40xx.s stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group Libraries
    ./Libraries/CMSIS/Include/: core_cm4.h
    ./Libraries/CMSIS/ST/STM32F4xx/Include/: system_stm32f4xx.h stm32f4xx.h
    ./Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_exti.h stm32f4xx_gpio.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_dma.h stm32f4xx_flash.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rtc.h stm32f4xx_sdio.h
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c
  group User
    ./User/: main.c globals.h gps.c gps.h serial.c serial.h timer.c timer.h
