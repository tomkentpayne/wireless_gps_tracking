# Keil uVision project TestingUART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: TestingUART +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\MAIN\Libraries\CMSIS\Include;..\MAIN\Libraries\CMSIS\ST\STM32F4xx\Include;..\MAIN\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\MAIN\Libraries\STM32F4xx_StdPeriph_Driver\src;..\MAIN\Default;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Default
    ../MAIN/Default/: startup_stm32f40xx.s stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group Libraries
    ../MAIN/Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_gpio.h stm32f4xx_tim.h stm32f4xx_usart.h
    ../MAIN/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ./User/: main.c
